# Keil uVision project Functional.uvprojx, settings and files
target Functional (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Functional
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\src;..\..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./src/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
    ./: main.c stm32f10x_systick.c stm32f10x_systick.h UART.c UART.h
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h
    ../ADC/: delay.c delay.h ADC.c ADC.h kalman.c kalman.h
    ../CCS811/: CCS811.c CCS811.h
  group startup
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Libraries
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_i2c.h stm32f10x_dma.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h stm32f10x_tim.h stm32f10x_adc.h
software components: CMSIS:CORE 5.1.1
